## tests/sensor_logic/testcase.yaml
```yaml
tests:
  app.sensor_logic:
    platform_allow:
      - native_sim
    tags: unit
```
